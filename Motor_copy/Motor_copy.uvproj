# Keil uVision project Motor_copy.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Motor_copy
  AfterMake: fromelf --bin -o build\Motor_copy_LPC1768.bin build\Motor_copy.axf
  c flags: Optim=1
  c define: TARGET_LPC1768,  TARGET_M3,  TARGET_NXP,  TARGET_LPC176X,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,
  c misc: --gnu
  c include: .;  Servo;  Driver;  Motor;  mbed;  mbed/TARGET_LPC1768;  mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD;  rosserial_arduino;  rosserial_mbed_lib;  rosserial_mbed_lib/roscpp;  rosserial_mbed_lib/nav_msgs;  rosserial_mbed_lib/tf;  rosserial_mbed_lib/topic_tools;  rosserial_mbed_lib/rosgraph_msgs;  rosserial_mbed_lib/rosserial_msgs;  rosserial_mbed_lib/MODSERIAL;  rosserial_mbed_lib/tests;  rosserial_mbed_lib/std_msgs;  rosserial_mbed_lib/sensor_msgs;  rosserial_mbed_lib/dianostic_msgs;  rosserial_mbed_lib/geometry_msgs;  rosserial_mbed_lib/ros;  IncrementalEncoder;  PID;  ADXL345_I2C;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  link misc: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/sys.o
                 
                mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/cmsis_nvic.o
                 
                mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/system_LPC17xx.o
                 
                mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/startup_LPC17xx.o
                 
                mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/retarget.o
                 
                mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    rosserial_mbed_lib/MODSERIAL/: ChangeLog.c FLUSH.cpp example_dma.cpp example2.cpp MODSERIAL.cpp example3a.cpp GETC.cpp ISR_TX.cpp example1.cpp INIT.cpp MODSERIAL_IRQ_INFO.cpp PUTC.cpp RESIZE.cpp ISR_RX.cpp example3b.cpp
    ./: imu_test2.cpp readimu.cpp HelloWorld.cpp Readfromkeyboard.cpp main.cpp imu_test.cpp
    Servo/: Servo.cpp
    Driver/: Driver.cpp
    Motor/: Motor.cpp
    rosserial_mbed_lib/: duration.cpp time.cpp
    rosserial_mbed_lib/tests/: float64_test.cpp time_test.cpp array_test.cpp
    IncrementalEncoder/: IncrementalEncoder.cpp
    PID/: PID.cpp
    ADXL345_I2C/: ADXL345_I2C.cpp
